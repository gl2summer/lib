# Keil uVision project lib.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lib (library)
  c flags: Optim=1
  c misc: --c99
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./src/: sll.c store_idx.c util.c
